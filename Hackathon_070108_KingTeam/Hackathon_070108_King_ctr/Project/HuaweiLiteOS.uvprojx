# Keil uVision project HuaweiLiteOS.uvprojx, settings and files
target HuaweiLiteOS (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HuaweiLiteOS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\Libraries\FWlib\inc;..\User;..\Huawei_LiteOS\kernel\include;..\Huawei_LiteOS\kernel\base\include;..\Huawei_LiteOS\platform\bsp\sample\config;..\Huawei_LiteOS\platform\cpu\arm\cortex-m4;..\User\src\include;..\User\include;..\User\src\mqtt;..\User\task
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: ..\User\Huawei_LiteOS.sct
  group Startup
    ../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLIB
    ../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../User/: main.c stm32f10x_it.c
  group HuaweiLiteOS_kernel
    ../Huawei_LiteOS/kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../Huawei_LiteOS/kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../Huawei_LiteOS/kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ../Huawei_LiteOS/kernel/base/misc/: los_misc.c
  group HuaweiLiteOS_platform
    ../Huawei_LiteOS/platform/bsp/sample/config/: los_config.c
    ../Huawei_LiteOS/platform/cpu/arm/cortex-m4/: los_hw.c los_hw_tick.c los_hwi.c los_dispatch.s
  group user_bsp
    ../User/src/init_conf/: mcu_init.c
    ../User/src/ult/: ult.c
    ../User/src/usart2/: usart2.c
    ../User/src/sht10/: sht10.c
    ../User/src/xassert/: _xassert.c
    ../User/src/bh1750_s/: bh1750_s.c i2c_s.c
    ../User/src/usart/: usart.c
    ../User/src/usart3/: usart3.c
    ../User/src/timer/: timer.c
  group user_task
    ../User/task/: task.c mqtt_task.c
  group jsmn
    ../User/src/jsmn/: jsmn.c
