# Keil uVision project HuaweiLiteOS.uvprojx, settings and files
target HuaweiLiteOS (ARM-ADS)
  device: STM32F103R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: HuaweiLiteOS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\Libraries\FWlib\inc;..\User;..\Huawei_LiteOS\kernel\include;..\Huawei_LiteOS\kernel\base\include;..\Huawei_LiteOS\platform\bsp\sample\config;..\Huawei_LiteOS\platform\cpu\arm\cortex-m4;..\HardWare\led;..\HardWare\usart;..\User\Delay;..\HardWare\Key;..\HardWare\Beep;..\User\Screen;..\HardWare\ChipID;..\HardWare\DS18B20;..\HardWare\PowerDown_Check;..\HardWare\PWMIN;..\HardWare\Water_Level;..\HardWare\PH;..\HardWare\Flash;..\HardWare\RTC;..\User\Slave_Control;..\HardWare\GPRS;..\HardWare\Can
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: ..\User\Huawei_LiteOS.sct
  group USER
    ../User/: main.c stm32f10x_it.c SelfDatGet.c Up2Server.c
    ../User/Delay/: Delay.c
    ../User/Screen/: Screen.c
    ../User/Slave_Control/: Slave_Control.c
  group HardWare
    ../HardWare/led/: bsp_led.c
    ../HardWare/usart/: bsp_usart.c Bsp_Uart2_Zgb.c Bsp_Uart3_A6.c
    ../HardWare/Key/: Bsp_Key.c
    ../HardWare/Beep/: Bsp_Beep.c
    ../HardWare/ChipID/: Bsp_ChipID.c
    ../HardWare/DS18B20/: Bsp_DS18B20.c
    ../HardWare/PWMIN/: Bsp_WaterPwmin_Tim3.c
    ../HardWare/PH/: Bsp_PH.c
    ../HardWare/Flash/: Bsp_Flash.c
    ../HardWare/Can/: Bsp_Can.c
    ../HardWare/GPRS/: Bsp_GPRS.c
    ../HardWare/RTC/: Bsp_RTC.c
    ../HardWare/PowerDown_Check/: Bsp_PowerDown.c
    ../HardWare/Water_Level/: Bsp_Water_Level.c
  group Startup
    ../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLIB
    ../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HuaweiLiteOS_kernel
    ../Huawei_LiteOS/kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../Huawei_LiteOS/kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../Huawei_LiteOS/kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ../Huawei_LiteOS/kernel/base/misc/: los_misc.c
  group HuaweiLiteOS_platform
    ../Huawei_LiteOS/platform/bsp/sample/config/: los_config.c
    ../Huawei_LiteOS/platform/cpu/arm/cortex-m4/: los_hw.c los_hw_tick.c los_hwi.c los_dispatch.s
