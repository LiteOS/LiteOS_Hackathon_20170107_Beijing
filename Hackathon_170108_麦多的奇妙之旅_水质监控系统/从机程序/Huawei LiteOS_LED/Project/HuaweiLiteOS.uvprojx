# Keil uVision project HuaweiLiteOS.uvprojx, settings and files
target HuaweiLiteOS (ARM-ADS)
  device: STM32F103R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: HuaweiLiteOS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\Libraries\FWlib\inc;..\User;..\Huawei_LiteOS\kernel\include;..\Huawei_LiteOS\kernel\base\include;..\Huawei_LiteOS\platform\bsp\sample\config;..\Huawei_LiteOS\platform\cpu\arm\cortex-m4;..\User\USART;..\Hardware\DS18B20;..\Hardware\PWMIN;..\Hardware\WDG;..\Hardware\led;..\Hardware\usart;..\Hardware\Water_Level;..\Hardware\PH;..\Hardware\ADC;..\User\Delay;..\Hardware\Flash;..\User\Delay;..\User\Touch2Master;..\Hardware\ChipID;..\Hardware\Key;..\Hardware\Can
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: ..\User\Huawei_LiteOS.sct
  group APP
    ../User/Delay/: Delay.c
    ../User/: SelfDatGet.c
    ../User/Touch2Master/: Touch2Master.c
  group USER
    ../User/: main.c stm32f10x_it.c
    ../Hardware/led/: bsp_led.c
    ../Hardware/usart/: bsp_usart.c bsp_usart2.c
    ../Hardware/DS18B20/: Bsp_DS18B20.c
    ../Hardware/PWMIN/: Bsp_WaterPwmin_Tim3.c
    ../Hardware/WDG/: Bsp_wdg.c
    ../Hardware/PH/: Bsp_PH.c
    ../Hardware/Water_Level/: Bsp_Water_Level.c
    ../Hardware/ADC/: Bsp_ADC.c
    ../Hardware/Flash/: Bsp_Flash.c
    ../Hardware/ChipID/: Bsp_ChipID.c
    ../Hardware/Key/: Bsp_Key.c
    ../Hardware/Can/: Bsp_Can.c
  group Startup
    ../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLIB
    ../Libraries/FWlib/src/: misc.c stm32f10x_can.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_adc.c stm32f10x_iwdg.c
  group HuaweiLiteOS_kernel
    ../Huawei_LiteOS/kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../Huawei_LiteOS/kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../Huawei_LiteOS/kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ../Huawei_LiteOS/kernel/base/misc/: los_misc.c
  group HuaweiLiteOS_platform
    ../Huawei_LiteOS/platform/bsp/sample/config/: los_config.c
    ../Huawei_LiteOS/platform/cpu/arm/cortex-m4/: los_hw.c los_hw_tick.c los_hwi.c los_dispatch.s
