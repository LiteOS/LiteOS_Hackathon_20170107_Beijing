# Keil uVision project FishMaster.uvprojx, settings and files
target FishMaster (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FishMaster
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\Libraries\inc;.\CMSIS;.\User;.\Headers;.\Kernel\include;.\Kernel\base\include;.\Platform\bsp\sample\config;.\Platform\cpu\arm\cortex-m4;.\Hardware\UART1;.\Hardware\OLED_IIC;.\Hardware\DS18B20;.\Hardware\UART2;.\Hardware\LED;.\Hardware\DO
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  scatter file: .\User\FishMaster.sct
  group STARTUP
    ./Startup/: startup_stm32f10x_hd.s
  group CMSIS
    ./CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ./Libraries/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group LiteOS_Kernel
    ./Kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ./Kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ./Kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ./Kernel/base/misc/: los_misc.c
  group LiteOS_Platform
    ./Platform/bsp/sample/config/: los_config.c
    ./Platform/cpu/arm/cortex-m4/: los_hw.c los_hw_tick.c los_hwi.c los_dispatch.s
  group USER
    ./User/: main.c stm32f10x_it.c
    ./Headers/: stm32f10x_conf.h stm32f10x_it.h
  group Hardware
    ./Hardware/DO/: DO.c
    ./Hardware/DS18B20/: DS18B20.c
    ./Hardware/LED/: bsp_led.c
    ./Hardware/OLED_IIC/: OLED_I2C.c
    ./Hardware/UART1/: usart.c
    ./Hardware/UART2/: usart2.c
