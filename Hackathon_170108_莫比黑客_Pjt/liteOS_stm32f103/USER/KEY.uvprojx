# Keil uVision project KEY.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.4
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: KEY +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\liteos\kernel\include;..\liteos\kernel\base\include;..\liteos\platform\bsp\sample\config;..\liteos\platform\cpu\arm\cortex-m4;..\HARDWARE\RGBLED;..\HARDWARE\TIMER;..\HARDWARE\CHE
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  scatter file: ..\OBJ\KEY.sct
  group USER
    ./: main.c stm32f10x_it.c
  group HARDWARE
    ./: system_stm32f10x.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/RGBLED/: RGB_LED.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/CHE/: che.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_tim.c
  group LiteOS_kernel
    ../liteos/kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../liteos/kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../liteos/kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ../liteos/kernel/base/misc/: los_misc.c
  group LiteOS_platform
    ../liteos/platform/bsp/sample/config/: los_config.c
    ../liteos/platform/cpu/arm/cortex-m4/: los_dispatch.s los_hw.c los_hw_tick.c los_hwi.c
software components: CMSIS:CORE 4.3.0
