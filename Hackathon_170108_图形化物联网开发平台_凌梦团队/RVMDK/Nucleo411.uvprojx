# Keil uVision project Nucleo411.uvprojx, settings and files
target Nucleo411 (ARM-ADS)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Nucleo411 +hex
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F411xE
  c include: ..\CMSIS;..\STM_Lib\inc;..\USER;..\Huawei_LiteOS\platform\bsp\sample\config;..\Huawei_LiteOS\platform\cpu\arm\cortex-m4;..\Huawei_LiteOS\kernel\base\include;..\Huawei_LiteOS\kernel\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group StartUp
    ../StartUp/: startup_stm32f411xe.s
  group CMSIS
    ../CMSIS/: system_stm32f4xx.c
  group STM_Lib
    ../STM_Lib/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c
  group USER
    ../USER/: main.c stm32f4xx_it.c usart.c delay.c proto.c CODE_LIST.c VM.c Mem.c ERROR_TYPE.c IO.c
  group Huawei_LiteOS_kernel
    ../Huawei_LiteOS/kernel/base/misc/: los_misc.c
    ../Huawei_LiteOS/kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ../Huawei_LiteOS/kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../Huawei_LiteOS/kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
  group Huawei_LiteOS_platform
    ../Huawei_LiteOS/platform/bsp/sample/config/: los_config.c
    ../Huawei_LiteOS/platform/cpu/arm/cortex-m4/: los_hw.c los_hw_tick.c los_hwi.c los_dispatch.s
