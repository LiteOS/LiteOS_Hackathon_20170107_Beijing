# Keil uVision project test.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F40_41xxx
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\Huawei_LiteOS\kernel\include;..\Huawei_LiteOS\kernel\base\include;..\Huawei_LiteOS\platform\bsp\sample\config;..\Huawei_LiteOS\platform\cpu\arm\cortex-m4
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\OBJ\test.sct
  group Source Group 1
    ./: startup_stm32f40_41xxx.s
  group USER
    ./: test.c command.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
  group LiteOS_Kernel
    ../Huawei_LiteOS/kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../Huawei_LiteOS/kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../Huawei_LiteOS/kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ../Huawei_LiteOS/kernel/base/misc/: los_misc.c
  group LiteOS_Platform
    ../Huawei_LiteOS/platform/bsp/sample/config/: los_config.c
    ../Huawei_LiteOS/platform/cpu/arm/cortex-m4/: los_hw.c los_hw_tick.c los_hwi.c los_dispatch.s
