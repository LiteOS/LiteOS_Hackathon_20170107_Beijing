# Keil uVision project iSO-STM32.uvprojx, settings and files
target Huawei_LiteOS (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 流水灯 +hex
  c flags: Optim=1 uC99=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\Led;..\..\Huawei_LiteOS_Kernel-master\Huawei_LiteOS\kernel\include;..\..\Huawei_LiteOS_Kernel-master\Huawei_LiteOS\kernel\base\include;..\..\Huawei_LiteOS_Kernel-master\Huawei_LiteOS\platform\bsp\sample\config;..\..\Huawei_LiteOS_Kernel-master\Huawei_LiteOS\platform\cpu\arm\cortex-m4;..\..\User\ESP8266;..\..\User\usart;..\..\User\Common;..\..\User\PM2d5;..\..\User\Key
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: ..\..\Output\流水灯.sct
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    ../../User/Led/: bsp_led.c
  group DOC
    ../../Doc/: readme.txt
  group Huawei_LiteOS_Kernel
    ../../Huawei_LiteOS_Kernel-master/Huawei_LiteOS/kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../Huawei_LiteOS_Kernel-master/Huawei_LiteOS/kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../Huawei_LiteOS_Kernel-master/Huawei_LiteOS/kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ../../Huawei_LiteOS_Kernel-master/Huawei_LiteOS/kernel/base/misc/: los_misc.c
  group Huawei_LiteOS_Platfrom
    ../../Huawei_LiteOS_Kernel-master/Huawei_LiteOS/platform/bsp/sample/config/: los_config.c
    ../../Huawei_LiteOS_Kernel-master/Huawei_LiteOS/platform/cpu/arm/cortex-m4/: los_hw.c los_hw_tick.c los_hwi.c los_dispatch.s
  group WIFI_ESP8266
    ../../User/ESP8266/: bsp_esp8266.c WIFI.c
  group usart
    ../../User/usart/: bsp_usart1.c
  group common
    ../../User/Common/: Common.c
  group PM2d5
    ../../User/PM2d5/: bsp_adc.c pm2d5.c
  group Key
    ../../User/Key/: bsp_key.c
software components: CMSIS:CORE 4.1.0
